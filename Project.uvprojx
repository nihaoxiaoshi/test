# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BOOT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\System;.\Hardware;.\UDSBase;.\UDSLogic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./System/: Delay.c Delay.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h bl_config.h
  group Hardware
    ./Hardware/: usart.c usart.h key.c key.h MyCAN.c MyCAN.h AES.c AES.h systick.c systick.h Timer.c Timer.h flash.c flash.h MyFlash.c MyFlash.h Store.c Store.h CRC32.c
  group UDSBase
    ./UDSBase/: uds_port.c uds_port.h uds_service.c uds_service.h uds_tp.c uds_tp.h uds_tp_private.h uds_type.h
  group UDSLogic
    ./UDSLogic/: service_cfg.c service_cfg.h SID2E_WriteDataByIdentifier.c SID2E_WriteDataByIdentifier.h SID3E_TesterPresent.c SID3E_TesterPresent.h SID10_SessionControl.c SID10_SessionControl.h SID11_EcuReset.c SID11_EcuReset.h SID14_ClearDiagnosticInformation.c SID14_ClearDiagnosticInformation.h SID19_ReadDTCInformation.c SID19_ReadDTCInformation.h SID22_ReadDataByIdentifier.c SID22_ReadDataByIdentifier.h SID27_SecurityAccess.c SID27_SecurityAccess.h SID28_CommunicationControl.c SID28_CommunicationControl.h SID31_RoutineControl.c SID31_RoutineControl.h SID34_RequestDownload.c SID34_RequestDownload.h SID36_TransferData.c SID36_TransferData.h SID37_RequestTransferExit.c SID37_RequestTransferExit.h SID85_ControlDTCSetting.c SID85_ControlDTCSetting.h
